# Keil uVision project RESTART.uvprojx, settings and files
target RESTART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RESTART +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\RESTART;.\RmLib;.\STLIB;.\USER;.\APP;.\BSP;.\Protocol;.\CH100;.\proto;.\CRCLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c config.h
    ./: readme.txt
  group TASK
    ./APP/: Control_Task.c Chassis_Task.c Remote_Task.c CanBusTask.c Camera_Gimbal_Task.c Gimbal_Task.c ModeSwitch.c Shoot_Task.c AutoAngle_Shoot.c Supervise.c AutoShoot_Control_Task.c Judge.c Vehicle_Com_Task.c Barriers_Task.c
    ./STLIB/: LADRC.c
  group BSP
    ./BSP/: bsp.c delay.c timer.c laser.c pwm.c led.c can1.c can2.c usart.c usart2.c usart3.c usart4.c output2vs.c protobuf-c.c client.c hi220.c TF02.c ddt_motor.c
  group STLIB
    ./STLIB/: startup_stm32f4xx.s misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c pid.c
    ./USER/: system_stm32f4xx.c stm32f4xx_it.c
  group RMLIB
    ./RmLib/: common.h fifo.h LostCounter.h pid_regulator.h ramp.h ramp_second.c ramp_second.h RMLib.lib
  group PROTOCAL
    ./Protocol/: MF_CRC16.h protocal.h Protocol.lib
  group CRCLIB
    ./CRCLIB/: crcLib.c
  group PROTO
    ./proto/: Recieve.pb-c.c Send.pb-c.c
  group CH100
    ./CH100/: AHRS_middleware.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Compiler:I/O:STDERR 1.2.0
